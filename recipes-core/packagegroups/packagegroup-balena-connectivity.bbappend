CONNECTIVITY_FIRMWARES:append = " \
    linux-firmware-iwlwifi-cc-a0 \
    linux-firmware-iwlwifi-9260 \
    linux-firmware-ibt-18-16-1 \
    linux-firmware-ibt-12-16 \
    linux-firmware-ibt-20-1-3 \
    "
